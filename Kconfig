## Kconfig
```kconfig
mainmenu "Dephy Ethernet"

source "Kconfig.zephyr"

config DEPHY_ETH
	bool "Dephy Ethernet module"
	default y
```
